# Keil uVision project ReceiveInfared.uvproj, settings and files
target ReceiveInfared (ARM-ADS)
  device: STM32L152VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ReceiveInfared +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\USER;.\FWlib\inc;.\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTCODE
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x_it.c ReceiveInfared.c usart.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
